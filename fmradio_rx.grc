options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Center Frequency
    start: 80.1e6
    step: '200000'
    stop: 108.1e6
    value: '99500000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Rx Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: signal_bandwidth
  id: variable
  parameters:
    comment: |-
      Adjust this value to set the 
      bandwidth of the signal
    value: '5000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: Volume
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.1'
    widget: dial
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: '200000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '7'
    cutoff_freq: samp_rate/2-20000
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: group member of pulse, pulse-access, and audio
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '0.5'
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,2,1
    label1: Tx
    showports: 'True'
    type: complex
    units: dBm
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: signal_bandwidth
    center_freq: center_freq
    dev_args: '0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [soapy_limesdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
