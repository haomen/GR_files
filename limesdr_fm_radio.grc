options:
  parameters:
    generate_options: qt_gui
    id: limesdr_fm
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 97.9e6
  states: {state: disabled}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: 90e6
    step: 100e3
    stop: 102e6
    value: 99.7e6
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: gain1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: int(samp_rate/channel_width)
    gain: gain1
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: channel_width
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: 50e3
    center_freq: center_freq
    gain: gain1
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [soapy_limesdr_source_0, '0', low_pass_filter_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
